# IAR project Ex1-OS.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $PROJ_DIR$; ..\..\..\..\..\..\ucos-ii\source; ..\..\..\..\..\..\ucos-ii\ports\avr\atmega128\iar; ..\BSP
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm128s.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group App
    ./: app.c app_cfg.h app_isr.s90 app_vect.s90 includes.h os_cfg.h
  group BSP
    ../BSP/: bsp.c bsp.h
  group uC/OS-II
    ../../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../../../../../uCOS-II/Ports/AVR/atmega128/IAR/: os_cpu.h
    ../../../../../../uCOS-II/Ports/AVR/Atmega128/IAR/: os_cpu_a.s90 os_cpu_c.c os_dbg.c
